# Keil uVision project NEW_TEMPLATE.uvproj, settings and files
target NEW_TEMPLATE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: NEW_TEMPLATE +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10X_FWLIB\inc;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\delay;..\HARDWARE\INFRARED_SAFE_DISTANCE;..\HARDWARE\System_LED;..\HARDWARE\TIMER;..\HARDWARE\Nokia510;..\HARDWARE\Ultrasonic
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10X_FWLIB
    ../STM32F10X_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group Infrared_safedistance
    ../HARDWARE/INFRARED_SAFE_DISTANCE/: InfraredSafeDistance.c
  group System_led
    ../HARDWARE/System_LED/: led.c
  group Timer
    ../HARDWARE/TIMER/: TIMER_INIT.c
  group Nokia5110
    ../HARDWARE/Nokia510/: LCD5110.C
  group Ultrasonic
    ../HARDWARE/Ultrasonic/: ultrasonic.c
